<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\paylard_rfm24_nrf24L01p.ewp</path>
  </project>
  <batchBuild />
</workspace>
