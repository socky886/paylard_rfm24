# Keil uVision project tx_rf.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: tx_rf +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\SYS\delay;..\SYS\sys;..\HARDWARE\LED;..\HARDWARE\UART;..\HARDWARE\KEY
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NRF24L01/: Si24R1.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYS
    ../SYS/delay/: delay.c
